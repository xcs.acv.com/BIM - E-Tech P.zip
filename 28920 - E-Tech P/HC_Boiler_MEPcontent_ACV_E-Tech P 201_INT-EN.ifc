Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project nummer
Time: 2021-06-29T09:50:14
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20170223_1515(x64) - Exporter 18.0.0.420 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Jun 29 09:50:14 2021 * Host: MBACIU-RO-DE * Database: C:\Users\MBaciu\AppData\Local\Temp\{79F41160-FCAC-4262-A059-8FB9C3658395}\ifc * Database version: 5507 * Database creation date: Tue Jun 29 09:50:13 2021 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Tue Jun 29 09:50:13 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Jun 29 09:50:13 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project nummer
LongName: Project omschrijving; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 23, 13, 199999; RefLongitude: -71, -14, -31, -199999; RefElevation: 0 mm
Dimensions - S4R_Use_nominal_diameter: yes
Other - Category: Project Information; Client Name: Klant naam; Project Address: Enter address here; Project Issue Date: Aanvraag datum; Project Name: Project omschrijving; Project Number: Project nummer; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Dimensions - S4R_Use_nominal_diameter: yes
Other - Category: Project Information; Client Name: Klant naam; Project Address: Enter address here; Project Issue Date: Aanvraag datum; Project Name: Project omschrijving; Project Number: Project nummer; Project Status: Project Status

# IfcBuildingStorey, V00
LongName: V00; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: Floor Level
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: GE_tag_level_floor_MEPcontent: standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: yes
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: V00; Structural: no
Other - Category: Levels; Family: Level: Floor Level; Family and Type: Level: Floor Level; Type: Level: Floor Level; Type Id: Level: Floor Level
Constraints(Type) - Elevation Base: Project Base Point

# IfcBoiler: E-Tech P 201, HC_Boiler_MEPcontent_ACV_E-Tech P_57-259_INT-EN:E-Tech P 201:1327910
In: V00
Type - PredefinedType: WATER; Material: Color RGB 222-222-222, Color RGB 237-028-036, Color RGB 040-040-040, Color RGB 002-128-024, Color RGB 073-073-073
Type - Dimensions - Depth: 567 mm; Height: 1495 mm; Hydronic Return Diameter: 100 mm; Hydronic Supply Diameter: 100 mm; Use Nominal Diameter: yes; Width: 542 mm
Type - Electrical - Frequency: 50 Hz; Max Power Boiler: 201600 W; Min Power Boiler: 50400 W; Phase: 3; Power Resistance (kW): 50.4 / 201.6; Rated Current (Fuse): 315 A; Voltage: 400 V
Type - Electrical - Loads - Power: 201600 W
Type - Identity Data - Article Type: E-Tech P 201; Base Family Version: 12.29; Content Supplier URL: www.MEPcontent.com; Copyright: © Trimble Europe BV; Custom: no; Description: Floor standing, high output 3-phase electric boiler. Use as a primary heat source or emergency back up; EMCS Version: 4.0; ETIM Article Class: EC010082; Family Version: 12.17; GLN: 5400891000007; Manufacturer: ACV; Manufacturer URL: https://www.acv.com/international/customer/dl/3713; MEPcontent Class: BOILER; Model: E-Tech P 201; OmniClass Number: 23.75.10.11.14; OmniClass Title: Hot Water Heat Generators; Revit Version: 2018; Type Name: E-Tech P 201; URL: https://mep.trimble.com; Watermarked By: https://mep.trimble.com
Type - Materials and Finishes - Black: Color RGB 040-040-040; Blue: Color RGB 129-158-173; Copper Connection: Color RGB 187-080-046; Dark Grey: Color RGB 073-073-073; Green: Color RGB 002-128-024; Light Grey: Color RGB 143-146-144; Red: Color RGB 237-028-036; White: Color RGB 222-222-222
Type - Mechanical - Maximum Supply Temperature (Operating Temperature): 90 kg/K/s3; Max Pressure Heating: 400000 Pa; Total Capacity: 0.102 m3; Weight: 187
Type - Other - Category: Mechanical Equipment; C: 1100 mm; DN Connection: yes; Family Name: HC_Boiler_MEPcontent_ACV_E-Tech P_57-259_INT-EN; Flange Offset: 328.5 mm; Front Clearance: 500 mm; Inch Connection: no; Nominal Diameter: 100 mm; Outer Diameter: 114.3 mm; Right Clearance: 500 mm
Type - Text - Article Description: Floor standing, high output 3-phase electric boiler. Use as a primary heat source or emergency back up; GTIN: 5400891001042; Manufacturer Art. No.: 00624801; Product Line: E-Tech P
Pset_ManufacturerTypeInformation - Manufacturer: ACV
Constraints - Offset: 0 mm
Dimensions - Area: 7.72563 m2; Volume: 0.457715 m3
Identity Data - Mark: 4
Mechanical - Hydronic Return Flow: 0 m3/s; Hydronic Supply Flow: 0 m3/s; System Classification: Hydronic Supply,Hydronic Return,Power
Other - Counter Flange Offset: 50 mm; Counter Flange Safe: no; Family: HC_Boiler_MEPcontent_ACV_E-Tech P_57-259_INT-EN: E-Tech P 201; Family and Type: HC_Boiler_MEPcontent_ACV_E-Tech P_57-259_INT-EN: E-Tech P 201; Reference Line Length: 100 mm; Type: HC_Boiler_MEPcontent_ACV_E-Tech P_57-259_INT-EN: E-Tech P 201; Type Id: HC_Boiler_MEPcontent_ACV_E-Tech P_57-259_INT-EN: E-Tech P 201
Phasing - Phase Created: 3. Nieuwbouw
Visibility - Counter Flange: no; Service Space: no
